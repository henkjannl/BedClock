#include <stdio.h>
#include "hp_pixel_buffer.h

static uint8_t v0_bytes[] = {
    0x00,0x0e,0x1f,0x1b,0x1b,0x1b,0x1b,0x1f,0x0e,0x00 };

static uint8_t v1_bytes[] = {
    0x00,0x04,0x06,0x07,0x06,0x06,0x06,0x06,0x06,0x00 };

static uint8_t v2_bytes[] = {
    0x00,0x1e,0x3f,0x33,0x38,0x1c,0x06,0x3f,0x3f,0x00 };

static uint8_t v3_bytes[] = {
    0x00,0x1e,0x3f,0x33,0x18,0x38,0x33,0x3f,0x1e,0x00 };

static uint8_t v4_bytes[] = {
    0x00,0x18,0x1c,0x1a,0x19,0x3f,0x3f,0x18,0x18,0x00 };

static uint8_t v5_bytes[] = {
    0x00,0x3e,0x3e,0x06,0x1e,0x30,0x30,0x3e,0x1e,0x00 };

static uint8_t v6_bytes[] = {
    0x00,0x1e,0x1f,0x03,0x1f,0x3f,0x33,0x3f,0x1e,0x00 };

static uint8_t v7_bytes[] = {
    0x00,0x3f,0x3f,0x38,0x1c,0x0c,0x0e,0x06,0x06,0x00 };

static uint8_t v8_bytes[] = {
    0x00,0x1e,0x33,0x33,0x1e,0x33,0x33,0x3f,0x1e,0x00 };

static uint8_t v9_bytes[] = {
    0x00,0x1e,0x33,0x33,0x3f,0x3e,0x30,0x3e,0x1e,0x00 };

static uint8_t v_colon_bytes[] = {
    0x00,0x00,0x00,0x03,0x03,0x00,0x00,0x03,0x03,0x00 };

static uint8_t v_d_bytes[] = {
    0x00,0x30,0x30,0x3e,0x3f,0x33,0x33,0x3f,0x3e,0x00 };

static uint8_t v_dot_bytes[] = {
    0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x03,0x03,0x00 };

static uint8_t v_e_bytes[] = {
    0x00,0x00,0x00,0x1e,0x33,0x23,0x3f,0x03,0x1e,0x00 };

static uint8_t v_g_bytes[] = {
    0x00,0x00,0x00,0x16,0x1b,0x1b,0x1b,0x1f,0x18,0x1f,0x0f };

static uint8_t v_h_bytes[] = {
    0x00,0x03,0x03,0x0f,0x1f,0x1b,0x1b,0x1b,0x1b,0x00 };

static uint8_t v_H__bytes[] = {
    0x00,0x33,0x33,0x33,0x3f,0x3f,0x33,0x33,0x33,0x00 };

static uint8_t v_i_bytes[] = {
    0x00,0x03,0x03,0x00,0x03,0x03,0x03,0x03,0x03,0x00 };

static uint8_t v_K_bytes[] = {
    0x00,0x63,0x73,0x3f,0x1f,0x3f,0x73,0x63,0x63,0x00 };

static uint8_t v_L_bytes[] = {
    0x00,0x03,0x03,0x03,0x03,0x03,0x03,0x1f,0x1f,0x00 };

static uint8_t v_m_bytes[] = {
    0x00,0x00,0x00,0x00,0x00,0x00,0x7f,0x00,0xff,0x00,0xdb,0x00,0xdb,0x00,0xdb,
    0x00,0xdb,0x00,0x00,0x00 };

static uint8_t v_M__bytes[] = {
    0x00,0x63,0x77,0x7f,0x6b,0x63,0x63,0x63,0x63,0x00 };

static uint8_t v_n_bytes[] = {
    0x00,0x00,0x00,0x0f,0x1f,0x1b,0x1b,0x1b,0x1b,0x00 };

static uint8_t v_o_bytes[] = {
    0x00,0x00,0x00,0x1e,0x3f,0x33,0x33,0x3f,0x1e,0x00 };

static uint8_t v_perc_bytes[] = {
    0x00,0x00,0x47,0x00,0xe5,0x00,0x77,0x00,0x38,0x00,0x1c,0x00,0xee,0x00,0xa7,
    0x00,0xe2,0x00,0x00,0x00 };

static uint8_t v_space_bytes[] = {
    0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00 };

static uint8_t v_V_bytes[] = {
    0x00,0x00,0xc3,0x00,0xc3,0x00,0x66,0x00,0x66,0x00,0x3c,0x00,0x3c,0x00,0x18,
    0x00,0x18,0x00,0x00,0x00 };

static uint8_t v_w_bytes[] = {
    0x00,0x00,0x00,0x00,0x00,0x00,0xdb,0x00,0xdb,0x00,0xff,0x00,0x7e,0x00,0x7e,
    0x00,0x24,0x00,0x00,0x00 };

static const hp_bitmap_t glyphs[] = {
    { .width = 6, .height = 10, .bitmap = v0_bytes, .mask = NULL },  // 0: '0'
    { .width = 5, .height = 10, .bitmap = v1_bytes, .mask = NULL },  // 1: '1'
    { .width = 7, .height = 10, .bitmap = v2_bytes, .mask = NULL },  // 2: '2'
    { .width = 7, .height = 10, .bitmap = v3_bytes, .mask = NULL },  // 3: '3'
    { .width = 7, .height = 10, .bitmap = v4_bytes, .mask = NULL },  // 4: '4'
    { .width = 7, .height = 10, .bitmap = v5_bytes, .mask = NULL },  // 5: '5'
    { .width = 7, .height = 10, .bitmap = v6_bytes, .mask = NULL },  // 6: '6'
    { .width = 7, .height = 10, .bitmap = v7_bytes, .mask = NULL },  // 7: '7'
    { .width = 7, .height = 10, .bitmap = v8_bytes, .mask = NULL },  // 8: '8'
    { .width = 7, .height = 10, .bitmap = v9_bytes, .mask = NULL },  // 9: '9'
    { .width = 3, .height = 10, .bitmap = v_colon_bytes, .mask = NULL },  // 10: ':'
    { .width = 7, .height = 10, .bitmap = v_d_bytes, .mask = NULL },  // 11: 'd'
    { .width = 3, .height = 10, .bitmap = v_dot_bytes, .mask = NULL },  // 12: '.'
    { .width = 7, .height = 10, .bitmap = v_e_bytes, .mask = NULL },  // 13: 'e'
    { .width = 6, .height = 11, .bitmap = v_g_bytes, .mask = NULL },  // 14: 'g'
    { .width = 6, .height = 10, .bitmap = v_h_bytes, .mask = NULL },  // 15: 'h'
    { .width = 7, .height = 10, .bitmap = v_H__bytes, .mask = NULL },  // 16: 'H_'
    { .width = 3, .height = 10, .bitmap = v_i_bytes, .mask = NULL },  // 17: 'i'
    { .width = 8, .height = 10, .bitmap = v_K_bytes, .mask = NULL },  // 18: 'K'
    { .width = 6, .height = 10, .bitmap = v_L_bytes, .mask = NULL },  // 19: 'L'
    { .width = 9, .height = 10, .bitmap = v_m_bytes, .mask = NULL },  // 20: 'm'
    { .width = 8, .height = 10, .bitmap = v_M__bytes, .mask = NULL },  // 21: 'M_'
    { .width = 6, .height = 10, .bitmap = v_n_bytes, .mask = NULL },  // 22: 'n'
    { .width = 7, .height = 10, .bitmap = v_o_bytes, .mask = NULL },  // 23: 'o'
    { .width = 9, .height = 10, .bitmap = v_perc_bytes, .mask = NULL },  // 24: '%'
    { .width = 5, .height = 10, .bitmap = v_space_bytes, .mask = NULL },  // 25: ' '
    { .width = 9, .height = 10, .bitmap = v_V_bytes, .mask = NULL },  // 26: 'V'
    { .width = 9, .height = 10, .bitmap = v_w_bytes, .mask = NULL },  // 27: 'w'
}; // const hp_bitmap_t glyphs[]

const hp_bitmap_t *hp_pixel_glyph(const unsigned char c) {
    if(c=='0') return &glyphs[0];
    if(c=='1') return &glyphs[1];
    if(c=='2') return &glyphs[2];
    if(c=='3') return &glyphs[3];
    if(c=='4') return &glyphs[4];
    if(c=='5') return &glyphs[5];
    if(c=='6') return &glyphs[6];
    if(c=='7') return &glyphs[7];
    if(c=='8') return &glyphs[8];
    if(c=='9') return &glyphs[9];
    if(c==':') return &glyphs[10];
    if(c=='d') return &glyphs[11];
    if(c=='.') return &glyphs[12];
    if(c=='e') return &glyphs[13];
    if(c=='g') return &glyphs[14];
    if(c=='h') return &glyphs[15];
    if(c=='H_') return &glyphs[16];
    if(c=='i') return &glyphs[17];
    if(c=='K') return &glyphs[18];
    if(c=='L') return &glyphs[19];
    if(c=='m') return &glyphs[20];
    if(c=='M_') return &glyphs[21];
    if(c=='n') return &glyphs[22];
    if(c=='o') return &glyphs[23];
    if(c=='%') return &glyphs[24];
    if(c==' ') return &glyphs[25];
    if(c=='V') return &glyphs[26];
    if(c=='w') return &glyphs[27];
  return NULL;
}