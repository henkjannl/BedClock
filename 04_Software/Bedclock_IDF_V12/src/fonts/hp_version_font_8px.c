#include <stdio.h>
#include "hp_version_font_8px.h"
#include "hp_pixel_buffer.h"

static uint8_t m0_bytes[] = {
    0x0c,0x1e,0x3f,0x3f,0x3f,0x3f,0x1e,0x0c };

static uint8_t m1_bytes[] = {
    0x04,0x0f,0x0f,0x0e,0x0e,0x0e,0x0e,0x04 };

static uint8_t m2_bytes[] = {
    0x1e,0x3f,0x3f,0x3c,0x1e,0x1f,0x3f,0x1e };

static uint8_t m3_bytes[] = {
    0x0c,0x1e,0x3f,0x3e,0x3c,0x3f,0x1e,0x0c };

static uint8_t m4_bytes[] = {
    0x08,0x1c,0x1e,0x1f,0x1f,0x3f,0x1e,0x08 };

static uint8_t m5_bytes[] = {
    0x1e,0x3f,0x1f,0x3f,0x3e,0x3e,0x1f,0x0e };

static uint8_t m6_bytes[] = {
    0x1c,0x3e,0x0f,0x1f,0x3f,0x3f,0x3e,0x1c };

static uint8_t m7_bytes[] = {
    0x1e,0x3f,0x3e,0x1c,0x1c,0x0e,0x0e,0x04 };

static uint8_t m8_bytes[] = {
    0x0c,0x1e,0x3f,0x1e,0x3f,0x3f,0x1e,0x0c };

static uint8_t m9_bytes[] = {
    0x0c,0x1e,0x3f,0x3f,0x3e,0x3c,0x1e,0x0c };

static uint8_t m_colon_bytes[] = {
    0x00,0x06,0x0f,0x0f,0x06,0x0f,0x0f,0x06 };

static uint8_t m_dot_bytes[] = {
    0x00,0x00,0x00,0x00,0x00,0x06,0x0f,0x06 };

static uint8_t m_K_bytes[] = {
    0x6f,0xff,0xff,0x3f,0x7f,0xff,0xef,0xef };

static uint8_t m_m_bytes[] = {
    0x00,0x17,0x3f,0x7f,0x7f,0x7f,0x7f,0x7f };

static uint8_t m_i_bytes[] = {
    0x02,0x07,0x07,0x07,0x07,0x07,0x07,0x07 };

static uint8_t m_n_bytes[] = {
    0x00,0x0f,0x3f,0x3f,0x3b,0x3b,0x3b,0x3f };

static uint8_t m_perc_bytes[] = {
    0xde,0xff,0x7f,0xff,0xfc,0xfe,0xff,0x7b };

static uint8_t m_space_bytes[] = {
    0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00 };

static uint8_t m_V_bytes[] = {
    0x42,0xe7,0xe7,0x7e,0x7e,0x3c,0x3c,0x18 };

static uint8_t v0_bytes[] = {
    0x00,0x0c,0x12,0x12,0x12,0x12,0x0c,0x00 };

static uint8_t v1_bytes[] = {
    0x00,0x04,0x06,0x04,0x04,0x04,0x04,0x00 };

static uint8_t v2_bytes[] = {
    0x00,0x0c,0x12,0x10,0x0c,0x02,0x1e,0x00 };

static uint8_t v3_bytes[] = {
    0x00,0x0c,0x12,0x18,0x10,0x12,0x0c,0x00 };

static uint8_t v4_bytes[] = {
    0x00,0x08,0x0c,0x0a,0x0a,0x1e,0x08,0x00 };

static uint8_t v5_bytes[] = {
    0x00,0x1e,0x02,0x1e,0x10,0x10,0x0e,0x00 };

static uint8_t v6_bytes[] = {
    0x00,0x1c,0x02,0x0e,0x12,0x12,0x1c,0x00 };

static uint8_t v7_bytes[] = {
    0x00,0x1e,0x10,0x08,0x08,0x04,0x04,0x00 };

static uint8_t v8_bytes[] = {
    0x00,0x0c,0x12,0x0c,0x12,0x12,0x0c,0x00 };

static uint8_t v9_bytes[] = {
    0x00,0x0c,0x12,0x12,0x1c,0x10,0x0c,0x00 };

static uint8_t v_colon_bytes[] = {
    0x00,0x00,0x06,0x06,0x00,0x06,0x06,0x00 };

static uint8_t v_dot_bytes[] = {
    0x00,0x00,0x00,0x00,0x00,0x00,0x06,0x00 };

static uint8_t v_space_bytes[] = {
    0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00 };

static uint8_t v_i_bytes[] = {
    0x00,0x02,0x00,0x02,0x02,0x02,0x02,0x00 };

static uint8_t v_K_bytes[] = {
    0x00,0x66,0x36,0x1e,0x3e,0x66,0x46,0x00 };

static uint8_t v_m_bytes[] = {
    0x00,0x00,0x16,0x2a,0x2a,0x2a,0x2a,0x00 };

static uint8_t v_n_bytes[] = {
    0x00,0x00,0x0e,0x12,0x12,0x12,0x12,0x00 };

static uint8_t v_perc_bytes[] = {
    0x00,0x4e,0x2a,0x1e,0x78,0x54,0x72,0x00 };

static uint8_t v_V_bytes[] = {
    0x00,0x42,0x42,0x24,0x24,0x18,0x18,0x00 };

static const hp_bitmap_t glyphs[] = {
    { .width = 6, .height = 8, .bitmap = v0_bytes, .mask = m0_bytes },
    { .width = 4, .height = 8, .bitmap = v1_bytes, .mask = m1_bytes },
    { .width = 6, .height = 8, .bitmap = v2_bytes, .mask = m2_bytes },
    { .width = 6, .height = 8, .bitmap = v3_bytes, .mask = m3_bytes },
    { .width = 6, .height = 8, .bitmap = v4_bytes, .mask = m4_bytes },
    { .width = 6, .height = 8, .bitmap = v5_bytes, .mask = m5_bytes },
    { .width = 6, .height = 8, .bitmap = v6_bytes, .mask = m6_bytes },
    { .width = 6, .height = 8, .bitmap = v7_bytes, .mask = m7_bytes },
    { .width = 6, .height = 8, .bitmap = v8_bytes, .mask = m8_bytes },
    { .width = 6, .height = 8, .bitmap = v9_bytes, .mask = m9_bytes },
    { .width = 4, .height = 8, .bitmap = v_colon_bytes, .mask = m_colon_bytes },  // 10 = ':'
    { .width = 4, .height = 8, .bitmap = v_dot_bytes, .mask = m_dot_bytes },      // 11 = '.'
    { .width = 4, .height = 8, .bitmap = v_space_bytes, .mask = m_space_bytes },  // 12 = ' '
    { .width = 7, .height = 8, .bitmap = v_m_bytes, .mask = m_m_bytes },          // 13 = 'm'
    { .width = 3, .height = 8, .bitmap = v_i_bytes, .mask = m_i_bytes },          // 14 = 'i'
    { .width = 6, .height = 8, .bitmap = v_n_bytes, .mask = m_n_bytes },          // 15 = 'n'
    { .width = 8, .height = 8, .bitmap = v_K_bytes, .mask = m_K_bytes },          // 16 = 'K'
    { .width = 8, .height = 8, .bitmap = v_V_bytes, .mask = m_V_bytes },          // 17 = 'V'
    { .width = 8, .height = 8, .bitmap = v_perc_bytes, .mask = m_perc_bytes },    // 18 = '%'
};

// Function that returns a bitmap given a character
const hp_bitmap_t *hp_version_font_8px(const unsigned char c) {

    if(c=='0') return &glyphs[0];
    if(c=='1') return &glyphs[1];
    if(c=='2') return &glyphs[2];
    if(c=='3') return &glyphs[3];
    if(c=='4') return &glyphs[4];
    if(c=='5') return &glyphs[5];
    if(c=='6') return &glyphs[6];
    if(c=='7') return &glyphs[7];
    if(c=='8') return &glyphs[8];
    if(c=='9') return &glyphs[9];
    if(c==':') return &glyphs[10];
    if(c=='.') return &glyphs[11];
    if(c==' ') return &glyphs[12];
    if(c=='m') return &glyphs[13];
    if(c=='i') return &glyphs[14];
    if(c=='n') return &glyphs[15];
    if(c=='K') return &glyphs[16];
    if(c=='V') return &glyphs[17];
    if(c=='%') return &glyphs[18];
    return NULL;
}
